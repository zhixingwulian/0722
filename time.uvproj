# Keil uVision project time.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: time
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\library\Device\Include;..\library\StdDriver\inc;..\library\StdDriver\src
  group Source Group 1
    ./: STARTUP.A51 timer.c
    ../library/StdDriver/src/: delay.c sys.c uart.c
